options:
  parameters:
    author: Shlesh Gholap
    generate_options: qt_gui
    id: lab8_t3c
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: np.pi
    samp_rate: '8000000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: '8000000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: E:\Acads\EE340_CommsLab\lab_11\final.txt
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: E:\Acads\EE340_CommsLab\lab_11\text.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_3
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '18'
    type: byte
  states: {}
- name: blocks_skiphead_1_0
  id: blocks_skiphead
  parameters:
    num_items: '43'
    type: float
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.15'
    init: '0'
    low: '-0.15'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1,1]'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: '1'
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '8'
    taps: '1'
    type: ccf
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '1'
    gain: '1'
    samp_rate: '400000'
    type: fir_filter_fff
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '8000000'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '20'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '3'
    ntaps: '88'
    samp_rate: '400000'
    sym_rate: '50000'
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_1_1
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '3'
    ntaps: '88'
    samp_rate: '400000'
    sym_rate: '50000'
    type: fir_filter_fff
  states: {}

connections:
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_3, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '0']
- [blocks_add_xx_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_real_0_0, '0', blocks_multiply_xx_0_3, '0']
- [blocks_file_source_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [blocks_float_to_uchar_0, '0', digital_diff_decoder_bb_0, '0']
- [blocks_multiply_xx_0_3, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_xx_1, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0_1, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0_0, '0', blocks_pack_k_bits_bb_0_1, '0']
- [blocks_skiphead_1_0, '0', fir_filter_xxx_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_diff_encoder_bb_0, '0']
- [digital_chunks_to_symbols_xx_0_1, '0', interp_fir_filter_xxx_0_0, '0']
- [digital_chunks_to_symbols_xx_0_1, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_skiphead_0_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0_1, '0']
- [fir_filter_xxx_0, '0', blocks_threshold_ff_0_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_2, '0']
- [interp_fir_filter_xxx_0_0, '0', root_raised_cosine_filter_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_1_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0_0, '0']
- [rational_resampler_xxx_1_0, '0', root_raised_cosine_filter_1_1, '0']
- [root_raised_cosine_filter_0, '0', rational_resampler_xxx_0, '0']
- [root_raised_cosine_filter_1_1, '0', blocks_skiphead_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
